# Keil uVision project DMA.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c Music.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
